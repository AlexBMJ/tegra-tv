DESCRIPTION = "Tegra base image"

require image-common.inc
