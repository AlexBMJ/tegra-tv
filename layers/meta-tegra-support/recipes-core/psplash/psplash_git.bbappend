FILESEXTRAPATHS:prepend:tegratv  := "${THISDIR}/files:"
SPLASH_IMAGES:tegratv = "file://psplash-OE4T-img.h;outsuffix=default"

